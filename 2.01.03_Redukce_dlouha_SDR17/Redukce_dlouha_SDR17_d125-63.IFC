Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: 2324151115.IFC
Time: 2018-07-25T14:56:50
Author: Dako
Written by: SwIFC
Made in: SolidWorks 2018

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 2324151115
In: Default Storey
PredefinedType: ELEMENT
