Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: 2523201315.IFC
Time: 2018-07-25T14:18:34
Author: Dako
Written by: SwIFC
Made in: SolidWorks 2018

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 2523201315
In: Default Storey
PredefinedType: ELEMENT
