Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: 2514124515.IFC
Time: 2018-08-22T08:24:16
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 2514124515
In: Default Storey
PredefinedType: ELEMENT
